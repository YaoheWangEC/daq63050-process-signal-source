# Keil uVision project process-signal-source-l021k8u7-4.uvprojx, settings and files
target process-signal-source-l021k8u7-4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32L021K8U7-4 ArteryTek
  pack: ArteryTek.AT32L021_DFP.2.0.7
  cpu: IRAM(0x20000000,0x2400) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: process-signal-source-l021k8u7-4 +hex
  AfterMake: keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32L021K8U7_4, USE_STDPERIPH_DRIVER, AT_START_L021_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm0plus\core_support;..\..\libraries\cmsis\cm0plus\device_support;..\inc;.\process-signal-source;.\process-signal-source\bsp;.\process-signal-source\bsp\oled;.\process-signal-source\command;../../middlewares/i2c_application_library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
  group app
    ./process-signal-source/: global_vars.c user.c
  group bsp
    ./process-signal-source/bsp/: bsp.c key.c
    ./process-signal-source/bsp/oled/: oled.c oled_io.c oledfont.c oled_canvas.c
  group user
    ../src/: at32l021_int.c at32l021_wk_config.c main.c wk_system.c wk_adc.c wk_i2c.c wk_spi.c wk_tmr.c wk_usart.c wk_gpio.c wk_dma.c i2c_app.c wk_wdt.c
  group firmware
    ../../libraries/drivers/src/: at32l021_crm.c at32l021_tmr.c at32l021_gpio.c at32l021_i2c.c at32l021_usart.c at32l021_pwc.c at32l021_adc.c at32l021_spi.c at32l021_dma.c at32l021_debug.c at32l021_flash.c at32l021_wdt.c at32l021_exint.c at32l021_misc.c
  group cmsis
    ../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
    ./: startup_at32l021.s
  group middlewares/i2c_application
    ../../middlewares/i2c_application_library/: i2c_application.c
  group command
    ./process-signal-source/command/: command_fifo.c command_handler.c command_io.c command_io_uart.c command_parser.c command_table.c
